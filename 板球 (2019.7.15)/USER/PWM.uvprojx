# Keil uVision project PWM.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\INIT;..\HARDWARE\LED;..\FUNC\MotorMove;..\HARDWARE\DataScope_DP;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\OpenMV;..\HARDWARE\MKEY;..\HARDWARE\LCD
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/INIT/: init.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DataScope_DP/: DataScope_DP.C
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/OpenMV/: OpenMV.c
    ../HARDWARE/MKEY/: MKEY.c
  group FUNC
    ../FUNC/MotorMove/: MotorMove.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_adc.c
  group README
    ../: README.TXT
